# Keil uVision project project.uvproj, settings and files
target Dashboard_2 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: project
  c flags: Optim=3 OneElfS=1
  c define: HSE_VALUE=8000000, USE_STDPERIPH_DRIVER
  c include: .\inc;.\inc\Core;.\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group inc
    ./inc/: stm32f4xx.h system_stm32f4xx.h stm32f4xx_periph.h
    ./inc/Core/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group src
    ./src/: system_stm32f4xx.c main.c startup_stm32f4xx.s Nmea.c stm32f4xx_it.c stm32f4xx_periph.c stm32f4xx_rcc.c misc_funct.c stm32f4xx_usart.c misc.c stm32f4xx_gpio.c stm32f4xx_init_rcc.c
